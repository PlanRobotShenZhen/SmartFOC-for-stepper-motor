# Keil uVision project PL_PMSM.uvprojx, settings and files
target BLDC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: N32G452CCL7 NSING
  pack: NSING.N32G45x_DFP.1.0.7
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PL_SM_DRIVER +hex
  AfterMake: fromelf.exe --bin --output Obj/PL_SM_DRIVER.bin Obj/PL_SM_DRIVER.axf
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Driver\n32g45x_std_periph_driver\inc;..\..\Driver\n32g45x_std_periph_driver\ARMASM;..\..\Driver\CMSIS\core;..\..\Driver\CMSIS\device;..\..\Board;..\..\Foc\inc;..\..\Six-step\Inc;..\..\Step_Motor\Inc;..\..\SRC;..\..\iqmath\include;..\..\iqmath\support;..\..\Modbus;..\..\Modbus\include;..\..\Modbus\rtu;..\..\Canfestival\canfestival-3-asc\include\cm4;..\..\Canfestival\canfestival-3-asc\include;..\..\Canfestival\canfestival-3-asc\cm4_driver;..\..\can_app;..\..\Canfestival;..\..\App\inc;.\LED_TEST
  asm include: ..\Head
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group RVMDK
    ./: main.c
    ../../Driver/CMSIS/device/startup/: startup_n32g45x.s
    ../../Driver/CMSIS/device/: system_n32g45x.c
  group App
    ../../App/src/: System_Init.c SystemClock.c Adc.c Spi.c Pwm_step.c
  group n32g45x_std_periph_driver
    ../../Driver/n32g45x_std_periph_driver/src/: misc.c n32g45x_adc.c n32g45x_bkp.c n32g45x_can.c n32g45x_comp.c n32g45x_crc.c n32g45x_dac.c n32g45x_dbg.c n32g45x_dma.c n32g45x_dvp.c n32g45x_eth.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_i2c.c n32g45x_iwdg.c n32g45x_pwr.c n32g45x_qspi.c n32g45x_rcc.c n32g45x_rtc.c n32g45x_sdio.c n32g45x_spi.c n32g45x_tim.c n32g45x_usart.c n32g45x_wwdg.c n32g45x_xfmc.c n32g45x_opamp.c
  group SRC
    ../../SRC/: Function.c SvpwmIsr.c Timer.c CIA402.c UartMode.c FLASH_WR.c Filter.c PidSpeed.c PidIqs.c PidTorque.c PidIds.c Pidposition.c Pidholding.c SpeedPlan2.c SVPWM_steper.c Pidc.c pidc.h Kalman.c
  group iqmath
    ../../iqmath/_IQNfunctions/: _atoIQN.c _IQNasin_acos.c _IQNatan2.c _IQNdiv.c _IQNexp.c _IQNfrac.c _IQNlog.c _IQNmpy.c _IQNmpyIQX.c _IQNrepeat.c _IQNrmpy.c _IQNrsmpy.c _IQNsin_cos.c _IQNsqrt.c _IQNtables.c _IQNtoa.c _IQNtoF.c _IQNversion.c
  group Modbus
    ../../Modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../../Modbus/rtu/: mbcrc.c mbrtu.c
    ../../Modbus/: mb.c portevent.c portserial.c porttimer.c uart_interface.c
  group CanFestival
    ../../Canfestival/canfestival-3-asc/src/: emcy.c lss.c lifegrd.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
    ../../Canfestival/: common.c log.c canfestival_usart.c
  group CanApp
    ../../can_app/: CANopen_interface.c Ds402_Slave.c Ds402_SlaveCb.c
  group LED_TEST
    ./LED_TEST/: led_test.c LED_TEST.h
